# ACM supports
CORE_IMAGE_EXTRA_INSTALL += " \
    acm-yang-module \
    \
    acm-demo \
    monitoring-client \
"
# kernel addons
CORE_IMAGE_EXTRA_INSTALL += " \
    kernel-module-acm \
"
