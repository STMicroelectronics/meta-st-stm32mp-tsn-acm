include tttech-license.inc

